Commit message: update english

File: frontend/public/urdf/eva_description/urdf/eva_description.urdf (robot description, URDF)
Before this commit: robot eva_description, 10 links, 9 joints
Joints:
- joint toolpoint_fixed_joint: origin xyz=0 0.17 0 rpy=0 0 0 -> xyz=0 0.17 0 rpy=1.5707963 0 0
